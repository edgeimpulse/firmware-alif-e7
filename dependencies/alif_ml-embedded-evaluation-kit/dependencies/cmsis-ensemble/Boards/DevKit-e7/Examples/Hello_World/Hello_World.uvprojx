# Keil uVision project Hello_World.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: AE722F80F55D5AE:M55_HP Alif Semiconductor
  pack: AlifSemiconductor.Ensemble.0.5.0-rc1
  cpu: IRAM(0x02000000,0x00400000) IRAM2(0x08000000,0x00280000) IROM(0x80000000,0x00580000) XRAM(0x50000000,0x00040000) XRAM2(0x50800000,0x00100000) XRAM3(0x60000000,0x00040000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Hello_World
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  asm define: TX_SINGLE_MODE_SECURE
  memory RVCT4: ROM 0x80000000 size 0x580000
  memory RVCT6: RAM 0x50000000 size 0x40000
  memory RVCT7: RAM 0x50800000 size 0x100000
  memory RVCT8: RAM 0x60000000 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x400000
  memory RVCT10: RAM 0x8000000 size 0x280000
  scatter file: .\RTE\Device\AE722F80F55D5AE_M55_HP\M55_HP.sct
  group Source Group 1
    ./: uart4_testApp.c
software components: CMSIS:CORE 5.6.0, RTOS:Kernel 6.1.3, Device:SOC Peripherals:PINCONF 1.0.0, Device:SOC Peripherals:USART 1.0.0, Device:Startup 1.0.0
